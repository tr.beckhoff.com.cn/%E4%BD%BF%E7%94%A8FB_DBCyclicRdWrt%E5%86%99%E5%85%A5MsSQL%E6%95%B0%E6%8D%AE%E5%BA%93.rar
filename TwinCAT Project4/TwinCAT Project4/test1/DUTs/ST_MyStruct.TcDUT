TYPE ST_MyStruct :
STRUCT
		ID		: DINT;
	Value	: REAL;
END_STRUCT
END_TYPE
